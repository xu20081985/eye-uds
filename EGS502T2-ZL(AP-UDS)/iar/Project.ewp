# IAR project Project.ewp, settings and files
configuration STM322xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205rx ST STM32F205rx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\library\inc; ..\sorce; ..\sorce\drive; ..\sorce\OS; ..\sorce\extern
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EGS502T2-ZL(AP)-V10X-X(2020XXXX)U.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drive
    ../sorce/drive/: DriveAdc.c DriveAdc.h DriveCan2.c DriveCan2.h DriveCrc.c DriveCrc.h DriverLis2dh.c DriverLis2dh.h DriveSysTick.c DriveSysTick.h DriveUsart1.c DriveUsart1.h DriveUsart2.c DriveUsart2.h DriveUsart6.c DriveUsart6.h e2prom_93C86.c e2prom_93C86.h FunctionIo.c FunctionIo.h includeDrive.h SpiFlash.c SpiFlash.h
  group extern
    ../sorce/extern/: encryption.a encryption.h
  group lib
    ../library/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_systick.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group lib/inc
    ../library/inc/: core_cm3.h misc.h stm32f10x_systick.h stm32f2xx.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h system_stm32f2xx.h
  group OS
    ../sorce/OS/: OS_EVENT.c OS_SYSTEM.h OS_TASK.c
  group source
    ../sorce/: AdapterParameter.c AdapterParameter.h AdapterSms.c AdapterSms.h EeyeLib.c EeyeLib.h GprsNetwork.c GprsNetwork.h hmacsha1.c hmacsha1.h include.h InterfaceIap.c InterfaceIap.h InterfaceInCom.c InterfaceInCom.h InterfaceSystem.c InterfaceSystem.h main.c main.h ManageAlarm.c ManageAlarm.h ManageBlindArea.c ManageBlindArea.h ManageBusPulse.c ManageBusPulse.h ManageCanBus.c ManageCanBus.h ManageDs18b20.c ManageDs18b20.h ManageExDev.c ManageExDev.h ManageFlashProgram.c ManageFlashProgram.h ManageKeyUnlock.c ManageKeyUnlock.h ManageLockCar.c ManageLockCar.h ManagePacketUpdate.c ManagePacketUpdate.h ManagePortControl.c ManagePortControl.h ManagePosTrack.c ManagePosTrack.h ManageProtocol.c ManageProtocol.h ManageRemoteUpdate.c ManageRemoteUpdate.h ManageTime.c manageTime.h ManageVoltSample.c ManageVoltSample.h ManageWatchdog.c ManageWatchdog.h ManageWorkStat.c MD5_NEW.c MD5_NEW.h MileMeter.c MileMeter.h ModuleGps.c ModuleGps.h myPrintf.c myPrintf.h NewBusOut.c NewBusOut.h platform_config.h rtc.c rtc.h stm32f2xx_conf.h stm32f2xx_it.c stm32f2xx_it.h
  group start
    ./: startup_stm32f2xx.s system_stm32f2xx.c
